ISO-10303-21;
HEADER;
FILE_DESCRIPTION(('STEP AP214'),'2;1');
FILE_NAME('part.step','',(''),(''),'','','');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
ENDSEC;
DATA;
#1=APPLICATION_CONTEXT('core data for automotive mechanical design processes');
#2=APPLICATION_PROTOCOL_DEFINITION('international standard','automotive_design',2000,#1);
#3=PRODUCT_CONTEXT('',#1,'mechanical');
#4=PRODUCT('Part','Part','',(#3));
#5=PRODUCT_RELATED_PRODUCT_CATEGORY('part','',(#4));
#6=PRODUCT_DEFINITION_FORMATION('','',#4);
#7=PRODUCT_DEFINITION_CONTEXT('part definition',#1,'design');
#8=PRODUCT_DEFINITION('design','',#6,#7);
#9=PRODUCT_DEFINITION_SHAPE('','',#8);
#10=(LENGTH_UNIT() NAMED_UNIT(*) SI_UNIT(.MILLI.,.METRE.));
#11=(NAMED_UNIT(*) PLANE_ANGLE_UNIT() SI_UNIT($,.RADIAN.));
#12=(NAMED_UNIT(*) SI_UNIT($,.STERADIAN.) SOLID_ANGLE_UNIT());
#13=UNCERTAINTY_MEASURE_WITH_UNIT(LENGTH_MEASURE(1.E-05),#10,'distance_accuracy_value','');
#14=(GEOMETRIC_REPRESENTATION_CONTEXT(3) GLOBAL_UNCERTAINTY_ASSIGNED_CONTEXT((#13)) GLOBAL_UNIT_ASSIGNED_CONTEXT((#10,
#11,#12)) REPRESENTATION_CONTEXT('',''));
#15=CARTESIAN_POINT('',(0.,0.,0.));
#16=DIRECTION('',(0.,0.,1.));
#17=DIRECTION('',(1.,0.,0.));
#18=AXIS2_PLACEMENT_3D('',#15,#16,#17);
#19=CARTESIAN_POINT('',(-21.9011792061119,5.7776116924099,2.54));
#20=DIRECTION('',(0.,1.,0.));
#21=DIRECTION('',(0.,0.,1.));
#22=AXIS2_PLACEMENT_3D('',#19,#20,#21);
#23=PLANE('',#22);
#24=CARTESIAN_POINT('',(-15.5611792061119,5.7776116924099,1.27));
#25=DIRECTION('',(0.,1.,0.));
#26=DIRECTION('',(0.,0.,1.));
#27=AXIS2_PLACEMENT_3D('',#24,#25,#26);
#28=CIRCLE('',#27,0.4);
#29=CARTESIAN_POINT('',(-15.5611792061119,5.7776116924099,1.67));
#30=VERTEX_POINT('',#29);
#31=CARTESIAN_POINT('',(-15.1611792061119,5.7776116924099,1.27));
#32=VERTEX_POINT('',#31);
#33=EDGE_CURVE('E45',#30,#32,#28,.T.);
#34=ORIENTED_EDGE('',*,*,#33,.T.);
#35=CARTESIAN_POINT('',(-15.5611792061119,5.7776116924099,1.27));
#36=DIRECTION('',(0.,1.,0.));
#37=DIRECTION('',(0.,0.,1.));
#38=AXIS2_PLACEMENT_3D('',#35,#36,#37);
#39=CIRCLE('',#38,0.4);
#40=CARTESIAN_POINT('',(-15.5611792061119,5.7776116924099,0.87));
#41=VERTEX_POINT('',#40);
#42=EDGE_CURVE('E11',#32,#41,#39,.T.);
#43=ORIENTED_EDGE('',*,*,#42,.T.);
#44=CARTESIAN_POINT('',(-15.5611792061119,5.7776116924099,1.27));
#45=DIRECTION('',(0.,1.,0.));
#46=DIRECTION('',(0.,0.,1.));
#47=AXIS2_PLACEMENT_3D('',#44,#45,#46);
#48=CIRCLE('',#47,0.4);
#49=CARTESIAN_POINT('',(-15.9611792061119,5.7776116924099,1.27));
#50=VERTEX_POINT('',#49);
#51=EDGE_CURVE('E577',#41,#50,#48,.T.);
#52=ORIENTED_EDGE('',*,*,#51,.T.);
#53=CARTESIAN_POINT('',(-15.5611792061119,5.7776116924099,1.27));
#54=DIRECTION('',(0.,1.,0.));
#55=DIRECTION('',(0.,0.,1.));
#56=AXIS2_PLACEMENT_3D('',#53,#54,#55);
#57=CIRCLE('',#56,0.4);
#58=EDGE_CURVE('E575',#50,#30,#57,.T.);
#59=ORIENTED_EDGE('',*,*,#58,.T.);
#60=EDGE_LOOP('',(#34,#43,#52,#59));
#61=FACE_BOUND('',#60,.T.);
#62=CARTESIAN_POINT('',(-18.1011792061119,5.7776116924099,1.27));
#63=DIRECTION('',(0.,1.,0.));
#64=DIRECTION('',(0.,0.,1.));
#65=AXIS2_PLACEMENT_3D('',#62,#63,#64);
#66=CIRCLE('',#65,0.4);
#67=CARTESIAN_POINT('',(-18.5011792061119,5.7776116924099,1.27));
#68=VERTEX_POINT('',#67);
#69=CARTESIAN_POINT('',(-18.1011792061119,5.7776116924099,1.67));
#70=VERTEX_POINT('',#69);
#71=EDGE_CURVE('E571',#68,#70,#66,.T.);
#72=ORIENTED_EDGE('',*,*,#71,.T.);
#73=CARTESIAN_POINT('',(-18.1011792061119,5.7776116924099,1.27));
#74=DIRECTION('',(0.,1.,0.));
#75=DIRECTION('',(0.,0.,1.));
#76=AXIS2_PLACEMENT_3D('',#73,#74,#75);
#77=CIRCLE('',#76,0.4);
#78=CARTESIAN_POINT('',(-17.7011792061119,5.7776116924099,1.27));
#79=VERTEX_POINT('',#78);
#80=EDGE_CURVE('E573',#70,#79,#77,.T.);
#81=ORIENTED_EDGE('',*,*,#80,.T.);
#82=CARTESIAN_POINT('',(-18.1011792061119,5.7776116924099,1.27));
#83=DIRECTION('',(0.,1.,0.));
#84=DIRECTION('',(0.,0.,1.));
#85=AXIS2_PLACEMENT_3D('',#82,#83,#84);
#86=CIRCLE('',#85,0.4);
#87=CARTESIAN_POINT('',(-18.1011792061119,5.7776116924099,0.87));
#88=VERTEX_POINT('',#87);
#89=EDGE_CURVE('E560',#79,#88,#86,.T.);
#90=ORIENTED_EDGE('',*,*,#89,.T.);
#91=CARTESIAN_POINT('',(-18.1011792061119,5.7776116924099,1.27));
#92=DIRECTION('',(0.,1.,0.));
#93=DIRECTION('',(0.,0.,1.));
#94=AXIS2_PLACEMENT_3D('',#91,#92,#93);
#95=CIRCLE('',#94,0.4);
#96=EDGE_CURVE('E563',#88,#68,#95,.T.);
#97=ORIENTED_EDGE('',*,*,#96,.T.);
#98=EDGE_LOOP('',(#72,#81,#90,#97));
#99=FACE_BOUND('',#98,.T.);
#100=CARTESIAN_POINT('',(-20.6411792061119,5.7776116924099,1.27));
#101=DIRECTION('',(0.,1.,0.));
#102=DIRECTION('',(0.,0.,1.));
#103=AXIS2_PLACEMENT_3D('',#100,#101,#102);
#104=CIRCLE('',#103,0.4);
#105=CARTESIAN_POINT('',(-21.0411792061119,5.7776116924099,1.27));
#106=VERTEX_POINT('',#105);
#107=CARTESIAN_POINT('',(-20.6411792061119,5.7776116924099,1.67));
#108=VERTEX_POINT('',#107);
#109=EDGE_CURVE('E567',#106,#108,#104,.T.);
#110=ORIENTED_EDGE('',*,*,#109,.T.);
#111=CARTESIAN_POINT('',(-20.6411792061119,5.7776116924099,1.27));
#112=DIRECTION('',(0.,1.,0.));
#113=DIRECTION('',(0.,0.,1.));
#114=AXIS2_PLACEMENT_3D('',#111,#112,#113);
#115=CIRCLE('',#114,0.4);
#116=CARTESIAN_POINT('',(-20.2411792061119,5.7776116924099,1.27));
#117=VERTEX_POINT('',#116);
#118=EDGE_CURVE('E569',#108,#117,#115,.T.);
#119=ORIENTED_EDGE('',*,*,#118,.T.);
#120=CARTESIAN_POINT('',(-20.6411792061119,5.7776116924099,1.27));
#121=DIRECTION('',(0.,1.,0.));
#122=DIRECTION('',(0.,0.,1.));
#123=AXIS2_PLACEMENT_3D('',#120,#121,#122);
#124=CIRCLE('',#123,0.4);
#125=CARTESIAN_POINT('',(-20.6411792061119,5.7776116924099,0.87));
#126=VERTEX_POINT('',#125);
#127=EDGE_CURVE('E557',#117,#126,#124,.T.);
#128=ORIENTED_EDGE('',*,*,#127,.T.);
#129=CARTESIAN_POINT('',(-20.6411792061119,5.7776116924099,1.27));
#130=DIRECTION('',(0.,1.,0.));
#131=DIRECTION('',(0.,0.,1.));
#132=AXIS2_PLACEMENT_3D('',#129,#130,#131);
#133=CIRCLE('',#132,0.4);
#134=EDGE_CURVE('E565',#126,#106,#133,.T.);
#135=ORIENTED_EDGE('',*,*,#134,.T.);
#136=EDGE_LOOP('',(#110,#119,#128,#135));
#137=FACE_BOUND('',#136,.T.);
#138=DIRECTION('',(1.,0.,0.));
#139=VECTOR('',#138,1.);
#140=CARTESIAN_POINT('',(-21.9011792061119,5.7776116924099,0.));
#141=LINE('',#140,#139);
#142=CARTESIAN_POINT('',(-21.9011792061119,5.7776116924099,0.));
#143=VERTEX_POINT('',#142);
#144=CARTESIAN_POINT('',(-14.3011792061119,5.7776116924099,0.));
#145=VERTEX_POINT('',#144);
#146=EDGE_CURVE('E507',#143,#145,#141,.T.);
#147=ORIENTED_EDGE('',*,*,#146,.T.);
#148=DIRECTION('',(0.,0.,-1.));
#149=VECTOR('',#148,1.);
#150=CARTESIAN_POINT('',(-14.3011792061119,5.7776116924099,2.54));
#151=LINE('',#150,#149);
#152=CARTESIAN_POINT('',(-14.3011792061119,5.7776116924099,2.54));
#153=VERTEX_POINT('',#152);
#154=EDGE_CURVE('E528',#153,#145,#151,.T.);
#155=ORIENTED_EDGE('',*,*,#154,.F.);
#156=DIRECTION('',(1.,0.,0.));
#157=VECTOR('',#156,1.);
#158=CARTESIAN_POINT('',(-21.9011792061119,5.7776116924099,2.54));
#159=LINE('',#158,#157);
#160=CARTESIAN_POINT('',(-21.9011792061119,5.7776116924099,2.54));
#161=VERTEX_POINT('',#160);
#162=EDGE_CURVE('E516',#161,#153,#159,.T.);
#163=ORIENTED_EDGE('',*,*,#162,.F.);
#164=DIRECTION('',(0.,0.,-1.));
#165=VECTOR('',#164,1.);
#166=CARTESIAN_POINT('',(-21.9011792061119,5.7776116924099,2.54));
#167=LINE('',#166,#165);
#168=EDGE_CURVE('E531',#161,#143,#167,.T.);
#169=ORIENTED_EDGE('',*,*,#168,.T.);
#170=EDGE_LOOP('',(#147,#155,#163,#169));
#171=FACE_BOUND('',#170,.T.);
#172=ADVANCED_FACE('F37',(#61,#99,#137,#171),#23,.F.);
#173=CARTESIAN_POINT('',(-21.9011792061119,5.7776116924099,2.54));
#174=DIRECTION('',(1.,0.,0.));
#175=DIRECTION('',(0.,0.,-1.));
#176=AXIS2_PLACEMENT_3D('',#173,#174,#175);
#177=PLANE('',#176);
#178=DIRECTION('',(0.,-1.,0.));
#179=VECTOR('',#178,1.);
#180=CARTESIAN_POINT('',(-21.9011792061119,5.7776116924099,0.));
#181=LINE('',#180,#179);
#182=CARTESIAN_POINT('',(-21.9011792061119,16.4276116924099,0.));
#183=VERTEX_POINT('',#182);
#184=EDGE_CURVE('E482',#183,#143,#181,.T.);
#185=ORIENTED_EDGE('',*,*,#184,.T.);
#186=ORIENTED_EDGE('',*,*,#168,.F.);
#187=DIRECTION('',(0.,-1.,0.));
#188=VECTOR('',#187,1.);
#189=CARTESIAN_POINT('',(-21.9011792061119,5.7776116924099,2.54));
#190=LINE('',#189,#188);
#191=CARTESIAN_POINT('',(-21.9011792061119,16.4276116924099,2.54));
#192=VERTEX_POINT('',#191);
#193=EDGE_CURVE('E513',#192,#161,#190,.T.);
#194=ORIENTED_EDGE('',*,*,#193,.F.);
#195=DIRECTION('',(0.,0.,-1.));
#196=VECTOR('',#195,1.);
#197=CARTESIAN_POINT('',(-21.9011792061119,16.4276116924099,2.54));
#198=LINE('',#197,#196);
#199=EDGE_CURVE('E522',#192,#183,#198,.T.);
#200=ORIENTED_EDGE('',*,*,#199,.T.);
#201=EDGE_LOOP('',(#185,#186,#194,#200));
#202=FACE_BOUND('',#201,.T.);
#203=ADVANCED_FACE('F39',(#202),#177,.F.);
#204=CARTESIAN_POINT('',(-14.3011792061119,5.7776116924099,2.54));
#205=DIRECTION('',(-1.,0.,0.));
#206=DIRECTION('',(0.,0.,1.));
#207=AXIS2_PLACEMENT_3D('',#204,#205,#206);
#208=PLANE('',#207);
#209=DIRECTION('',(0.,1.,0.));
#210=VECTOR('',#209,1.);
#211=CARTESIAN_POINT('',(-14.3011792061119,5.7776116924099,0.));
#212=LINE('',#211,#210);
#213=CARTESIAN_POINT('',(-14.3011792061119,16.4276116924099,0.));
#214=VERTEX_POINT('',#213);
#215=EDGE_CURVE('E509',#145,#214,#212,.T.);
#216=ORIENTED_EDGE('',*,*,#215,.T.);
#217=DIRECTION('',(0.,0.,-1.));
#218=VECTOR('',#217,1.);
#219=CARTESIAN_POINT('',(-14.3011792061119,16.4276116924099,2.54));
#220=LINE('',#219,#218);
#221=CARTESIAN_POINT('',(-14.3011792061119,16.4276116924099,2.54));
#222=VERTEX_POINT('',#221);
#223=EDGE_CURVE('E525',#222,#214,#220,.T.);
#224=ORIENTED_EDGE('',*,*,#223,.F.);
#225=DIRECTION('',(0.,1.,0.));
#226=VECTOR('',#225,1.);
#227=CARTESIAN_POINT('',(-14.3011792061119,5.7776116924099,2.54));
#228=LINE('',#227,#226);
#229=EDGE_CURVE('E518',#153,#222,#228,.T.);
#230=ORIENTED_EDGE('',*,*,#229,.F.);
#231=ORIENTED_EDGE('',*,*,#154,.T.);
#232=EDGE_LOOP('',(#216,#224,#230,#231));
#233=FACE_BOUND('',#232,.T.);
#234=ADVANCED_FACE('F620',(#233),#208,.F.);
#235=CARTESIAN_POINT('',(-21.9011792061119,16.4276116924099,2.54));
#236=DIRECTION('',(0.,-1.,0.));
#237=DIRECTION('',(0.,0.,-1.));
#238=AXIS2_PLACEMENT_3D('',#235,#236,#237);
#239=PLANE('',#238);
#240=DIRECTION('',(-1.,0.,0.));
#241=VECTOR('',#240,1.);
#242=CARTESIAN_POINT('',(-21.9011792061119,16.4276116924099,0.));
#243=LINE('',#242,#241);
#244=EDGE_CURVE('E511',#214,#183,#243,.T.);
#245=ORIENTED_EDGE('',*,*,#244,.T.);
#246=ORIENTED_EDGE('',*,*,#199,.F.);
#247=DIRECTION('',(-1.,0.,0.));
#248=VECTOR('',#247,1.);
#249=CARTESIAN_POINT('',(-21.9011792061119,16.4276116924099,2.54));
#250=LINE('',#249,#248);
#251=EDGE_CURVE('E520',#222,#192,#250,.T.);
#252=ORIENTED_EDGE('',*,*,#251,.F.);
#253=ORIENTED_EDGE('',*,*,#223,.T.);
#254=EDGE_LOOP('',(#245,#246,#252,#253));
#255=FACE_BOUND('',#254,.T.);
#256=ADVANCED_FACE('F625',(#255),#239,.F.);
#257=CARTESIAN_POINT('',(-21.9011792061119,16.4276116924099,2.54));
#258=DIRECTION('',(0.,0.,-1.));
#259=DIRECTION('',(-1.,0.,0.));
#260=AXIS2_PLACEMENT_3D('',#257,#258,#259);
#261=PLANE('',#260);
#262=DIRECTION('',(0.866025403784439,-0.499999999999999,0.));
#263=VECTOR('',#262,1.);
#264=CARTESIAN_POINT('',(-16.1894740070577,10.930284170127,2.54));
#265=LINE('',#264,#263);
#266=CARTESIAN_POINT('',(-17.0554994108421,11.430284170127,2.54));
#267=VERTEX_POINT('',#266);
#268=CARTESIAN_POINT('',(-16.1894740070577,10.930284170127,2.54));
#269=VERTEX_POINT('',#268);
#270=EDGE_CURVE('E410',#267,#269,#265,.T.);
#271=ORIENTED_EDGE('',*,*,#270,.F.);
#272=CARTESIAN_POINT('',(-18.1011792061119,12.6113579506018,2.54));
#273=DIRECTION('',(0.,0.,1.));
#274=DIRECTION('',(1.,0.,0.));
#275=AXIS2_PLACEMENT_3D('',#272,#273,#274);
#276=CIRCLE('',#275,1.57746046199599);
#277=CARTESIAN_POINT('',(-19.1468590013818,11.430284170127,2.54));
#278=VERTEX_POINT('',#277);
#279=EDGE_CURVE('E408',#278,#267,#276,.T.);
#280=ORIENTED_EDGE('',*,*,#279,.F.);
#281=DIRECTION('',(0.866025403784436,0.500000000000004,0.));
#282=VECTOR('',#281,1.);
#283=CARTESIAN_POINT('',(-20.0128844051662,10.930284170127,2.54));
#284=LINE('',#283,#282);
#285=CARTESIAN_POINT('',(-20.0128844051662,10.930284170127,2.54));
#286=VERTEX_POINT('',#285);
#287=EDGE_CURVE('E440',#286,#278,#284,.T.);
#288=ORIENTED_EDGE('',*,*,#287,.F.);
#289=DIRECTION('',(0.500000000000001,-0.866025403784438,0.));
#290=VECTOR('',#289,1.);
#291=CARTESIAN_POINT('',(-20.5128844051662,11.7963095739114,2.54));
#292=LINE('',#291,#290);
#293=CARTESIAN_POINT('',(-20.5128844051662,11.7963095739114,2.54));
#294=VERTEX_POINT('',#293);
#295=EDGE_CURVE('E437',#294,#286,#292,.T.);
#296=ORIENTED_EDGE('',*,*,#295,.F.);
#297=DIRECTION('',(-0.866025403784439,-0.5,0.));
#298=VECTOR('',#297,1.);
#299=CARTESIAN_POINT('',(-20.5128844051662,11.7963095739114,2.54));
#300=LINE('',#299,#298);
#301=CARTESIAN_POINT('',(-19.6468590013818,12.2963095739114,2.54));
#302=VERTEX_POINT('',#301);
#303=EDGE_CURVE('E434',#302,#294,#300,.T.);
#304=ORIENTED_EDGE('',*,*,#303,.F.);
#305=CARTESIAN_POINT('',(-18.1011792061119,12.6113579506018,2.54));
#306=DIRECTION('',(0.,0.,1.));
#307=DIRECTION('',(1.,0.,0.));
#308=AXIS2_PLACEMENT_3D('',#305,#306,#307);
#309=CIRCLE('',#308,1.57746046199599);
#310=CARTESIAN_POINT('',(-18.6011792061119,14.107480107767,2.54));
#311=VERTEX_POINT('',#310);
#312=EDGE_CURVE('E431',#311,#302,#309,.T.);
#313=ORIENTED_EDGE('',*,*,#312,.F.);
#314=DIRECTION('',(0.,-1.,0.));
#315=VECTOR('',#314,1.);
#316=CARTESIAN_POINT('',(-18.6011792061119,15.107480107767,2.54));
#317=LINE('',#316,#315);
#318=CARTESIAN_POINT('',(-18.6011792061119,15.107480107767,2.54));
#319=VERTEX_POINT('',#318);
#320=EDGE_CURVE('E428',#319,#311,#317,.T.);
#321=ORIENTED_EDGE('',*,*,#320,.F.);
#322=DIRECTION('',(-1.,0.,0.));
#323=VECTOR('',#322,1.);
#324=CARTESIAN_POINT('',(-18.6011792061119,15.107480107767,2.54));
#325=LINE('',#324,#323);
#326=CARTESIAN_POINT('',(-17.6011792061119,15.107480107767,2.54));
#327=VERTEX_POINT('',#326);
#328=EDGE_CURVE('E425',#327,#319,#325,.T.);
#329=ORIENTED_EDGE('',*,*,#328,.F.);
#330=DIRECTION('',(0.,1.,0.));
#331=VECTOR('',#330,1.);
#332=CARTESIAN_POINT('',(-17.6011792061119,15.107480107767,2.54));
#333=LINE('',#332,#331);
#334=CARTESIAN_POINT('',(-17.6011792061119,14.107480107767,2.54));
#335=VERTEX_POINT('',#334);
#336=EDGE_CURVE('E422',#335,#327,#333,.T.);
#337=ORIENTED_EDGE('',*,*,#336,.F.);
#338=CARTESIAN_POINT('',(-18.1011792061119,12.6113579506018,2.54));
#339=DIRECTION('',(0.,0.,1.));
#340=DIRECTION('',(-1.,0.,0.));
#341=AXIS2_PLACEMENT_3D('',#338,#339,#340);
#342=CIRCLE('',#341,1.57746046199599);
#343=CARTESIAN_POINT('',(-16.5554994108421,12.2963095739114,2.54));
#344=VERTEX_POINT('',#343);
#345=EDGE_CURVE('E419',#344,#335,#342,.T.);
#346=ORIENTED_EDGE('',*,*,#345,.F.);
#347=DIRECTION('',(-0.866025403784439,0.499999999999999,0.));
#348=VECTOR('',#347,1.);
#349=CARTESIAN_POINT('',(-15.6894740070577,11.7963095739114,2.54));
#350=LINE('',#349,#348);
#351=CARTESIAN_POINT('',(-15.6894740070577,11.7963095739114,2.54));
#352=VERTEX_POINT('',#351);
#353=EDGE_CURVE('E416',#352,#344,#350,.T.);
#354=ORIENTED_EDGE('',*,*,#353,.F.);
#355=DIRECTION('',(0.499999999999995,0.866025403784441,0.));
#356=VECTOR('',#355,1.);
#357=CARTESIAN_POINT('',(-16.1894740070577,10.930284170127,2.54));
#358=LINE('',#357,#356);
#359=EDGE_CURVE('E413',#269,#352,#358,.T.);
#360=ORIENTED_EDGE('',*,*,#359,.F.);
#361=EDGE_LOOP('',(#271,#280,#288,#296,#304,#313,#321,#329,#337,#346,#354,#360));
#362=FACE_BOUND('',#361,.T.);
#363=ORIENTED_EDGE('',*,*,#193,.T.);
#364=ORIENTED_EDGE('',*,*,#162,.T.);
#365=ORIENTED_EDGE('',*,*,#229,.T.);
#366=ORIENTED_EDGE('',*,*,#251,.T.);
#367=EDGE_LOOP('',(#363,#364,#365,#366));
#368=FACE_BOUND('',#367,.T.);
#369=ADVANCED_FACE('F629',(#362,#368),#261,.F.);
#370=CARTESIAN_POINT('',(-21.9011792061119,16.4276116924099,0.));
#371=DIRECTION('',(0.,0.,-1.));
#372=DIRECTION('',(-1.,0.,0.));
#373=AXIS2_PLACEMENT_3D('',#370,#371,#372);
#374=PLANE('',#373);
#375=CARTESIAN_POINT('',(-18.1011792061119,12.6113579506018,0.));
#376=DIRECTION('',(0.,0.,1.));
#377=DIRECTION('',(1.,0.,0.));
#378=AXIS2_PLACEMENT_3D('',#375,#376,#377);
#379=CIRCLE('',#378,1.57746046199599);
#380=CARTESIAN_POINT('',(-19.1468590013818,11.430284170127,0.));
#381=VERTEX_POINT('',#380);
#382=CARTESIAN_POINT('',(-17.0554994108421,11.430284170127,0.));
#383=VERTEX_POINT('',#382);
#384=EDGE_CURVE('E443',#381,#383,#379,.T.);
#385=ORIENTED_EDGE('',*,*,#384,.T.);
#386=DIRECTION('',(0.866025403784439,-0.499999999999999,0.));
#387=VECTOR('',#386,1.);
#388=CARTESIAN_POINT('',(-16.1894740070577,10.930284170127,0.));
#389=LINE('',#388,#387);
#390=CARTESIAN_POINT('',(-16.1894740070577,10.930284170127,0.));
#391=VERTEX_POINT('',#390);
#392=EDGE_CURVE('E446',#383,#391,#389,.T.);
#393=ORIENTED_EDGE('',*,*,#392,.T.);
#394=DIRECTION('',(0.499999999999995,0.866025403784441,0.));
#395=VECTOR('',#394,1.);
#396=CARTESIAN_POINT('',(-16.1894740070577,10.930284170127,0.));
#397=LINE('',#396,#395);
#398=CARTESIAN_POINT('',(-15.6894740070577,11.7963095739114,0.));
#399=VERTEX_POINT('',#398);
#400=EDGE_CURVE('E449',#391,#399,#397,.T.);
#401=ORIENTED_EDGE('',*,*,#400,.T.);
#402=DIRECTION('',(-0.866025403784439,0.499999999999999,0.));
#403=VECTOR('',#402,1.);
#404=CARTESIAN_POINT('',(-15.6894740070577,11.7963095739114,0.));
#405=LINE('',#404,#403);
#406=CARTESIAN_POINT('',(-16.5554994108421,12.2963095739114,0.));
#407=VERTEX_POINT('',#406);
#408=EDGE_CURVE('E452',#399,#407,#405,.T.);
#409=ORIENTED_EDGE('',*,*,#408,.T.);
#410=CARTESIAN_POINT('',(-18.1011792061119,12.6113579506018,0.));
#411=DIRECTION('',(0.,0.,1.));
#412=DIRECTION('',(-1.,0.,0.));
#413=AXIS2_PLACEMENT_3D('',#410,#411,#412);
#414=CIRCLE('',#413,1.57746046199599);
#415=CARTESIAN_POINT('',(-17.6011792061119,14.107480107767,0.));
#416=VERTEX_POINT('',#415);
#417=EDGE_CURVE('E455',#407,#416,#414,.T.);
#418=ORIENTED_EDGE('',*,*,#417,.T.);
#419=DIRECTION('',(0.,1.,0.));
#420=VECTOR('',#419,1.);
#421=CARTESIAN_POINT('',(-17.6011792061119,15.107480107767,0.));
#422=LINE('',#421,#420);
#423=CARTESIAN_POINT('',(-17.6011792061119,15.107480107767,0.));
#424=VERTEX_POINT('',#423);
#425=EDGE_CURVE('E458',#416,#424,#422,.T.);
#426=ORIENTED_EDGE('',*,*,#425,.T.);
#427=DIRECTION('',(-1.,0.,0.));
#428=VECTOR('',#427,1.);
#429=CARTESIAN_POINT('',(-18.6011792061119,15.107480107767,0.));
#430=LINE('',#429,#428);
#431=CARTESIAN_POINT('',(-18.6011792061119,15.107480107767,0.));
#432=VERTEX_POINT('',#431);
#433=EDGE_CURVE('E461',#424,#432,#430,.T.);
#434=ORIENTED_EDGE('',*,*,#433,.T.);
#435=DIRECTION('',(0.,-1.,0.));
#436=VECTOR('',#435,1.);
#437=CARTESIAN_POINT('',(-18.6011792061119,15.107480107767,0.));
#438=LINE('',#437,#436);
#439=CARTESIAN_POINT('',(-18.6011792061119,14.107480107767,0.));
#440=VERTEX_POINT('',#439);
#441=EDGE_CURVE('E464',#432,#440,#438,.T.);
#442=ORIENTED_EDGE('',*,*,#441,.T.);
#443=CARTESIAN_POINT('',(-18.1011792061119,12.6113579506018,0.));
#444=DIRECTION('',(0.,0.,1.));
#445=DIRECTION('',(1.,0.,0.));
#446=AXIS2_PLACEMENT_3D('',#443,#444,#445);
#447=CIRCLE('',#446,1.57746046199599);
#448=CARTESIAN_POINT('',(-19.6468590013818,12.2963095739114,0.));
#449=VERTEX_POINT('',#448);
#450=EDGE_CURVE('E467',#440,#449,#447,.T.);
#451=ORIENTED_EDGE('',*,*,#450,.T.);
#452=DIRECTION('',(-0.866025403784439,-0.5,0.));
#453=VECTOR('',#452,1.);
#454=CARTESIAN_POINT('',(-20.5128844051662,11.7963095739114,0.));
#455=LINE('',#454,#453);
#456=CARTESIAN_POINT('',(-20.5128844051662,11.7963095739114,0.));
#457=VERTEX_POINT('',#456);
#458=EDGE_CURVE('E470',#449,#457,#455,.T.);
#459=ORIENTED_EDGE('',*,*,#458,.T.);
#460=DIRECTION('',(0.500000000000001,-0.866025403784438,0.));
#461=VECTOR('',#460,1.);
#462=CARTESIAN_POINT('',(-20.5128844051662,11.7963095739114,0.));
#463=LINE('',#462,#461);
#464=CARTESIAN_POINT('',(-20.0128844051662,10.930284170127,0.));
#465=VERTEX_POINT('',#464);
#466=EDGE_CURVE('E473',#457,#465,#463,.T.);
#467=ORIENTED_EDGE('',*,*,#466,.T.);
#468=DIRECTION('',(0.866025403784436,0.500000000000004,0.));
#469=VECTOR('',#468,1.);
#470=CARTESIAN_POINT('',(-20.0128844051662,10.930284170127,0.));
#471=LINE('',#470,#469);
#472=EDGE_CURVE('E476',#465,#381,#471,.T.);
#473=ORIENTED_EDGE('',*,*,#472,.T.);
#474=EDGE_LOOP('',(#385,#393,#401,#409,#418,#426,#434,#442,#451,#459,#467,#473));
#475=FACE_BOUND('',#474,.T.);
#476=ORIENTED_EDGE('',*,*,#184,.F.);
#477=ORIENTED_EDGE('',*,*,#244,.F.);
#478=ORIENTED_EDGE('',*,*,#215,.F.);
#479=ORIENTED_EDGE('',*,*,#146,.F.);
#480=EDGE_LOOP('',(#476,#477,#478,#479));
#481=FACE_BOUND('',#480,.T.);
#482=ADVANCED_FACE('F633',(#475,#481),#374,.T.);
#483=CARTESIAN_POINT('',(-18.1011792061119,12.6113579506018,0.));
#484=DIRECTION('',(0.,0.,1.));
#485=DIRECTION('',(1.,0.,0.));
#486=AXIS2_PLACEMENT_3D('',#483,#484,#485);
#487=CYLINDRICAL_SURFACE('',#486,1.57746046199599);
#488=ORIENTED_EDGE('',*,*,#279,.T.);
#489=DIRECTION('',(0.,0.,1.));
#490=VECTOR('',#489,1.);
#491=CARTESIAN_POINT('',(-17.0554994108421,11.430284170127,0.));
#492=LINE('',#491,#490);
#493=EDGE_CURVE('E479',#383,#267,#492,.T.);
#494=ORIENTED_EDGE('',*,*,#493,.F.);
#495=ORIENTED_EDGE('',*,*,#384,.F.);
#496=DIRECTION('',(0.,0.,1.));
#497=VECTOR('',#496,1.);
#498=CARTESIAN_POINT('',(-19.1468590013818,11.430284170127,0.));
#499=LINE('',#498,#497);
#500=EDGE_CURVE('E480',#381,#278,#499,.T.);
#501=ORIENTED_EDGE('',*,*,#500,.T.);
#502=EDGE_LOOP('',(#488,#494,#495,#501));
#503=FACE_BOUND('',#502,.T.);
#504=ADVANCED_FACE('F637',(#503),#487,.F.);
#505=CARTESIAN_POINT('',(-20.0128844051662,10.930284170127,0.));
#506=DIRECTION('',(0.500000000000004,-0.866025403784436,0.));
#507=DIRECTION('',(0.866025403784436,0.500000000000004,0.));
#508=AXIS2_PLACEMENT_3D('',#505,#506,#507);
#509=PLANE('',#508);
#510=ORIENTED_EDGE('',*,*,#287,.T.);
#511=ORIENTED_EDGE('',*,*,#500,.F.);
#512=ORIENTED_EDGE('',*,*,#472,.F.);
#513=DIRECTION('',(0.,0.,1.));
#514=VECTOR('',#513,1.);
#515=CARTESIAN_POINT('',(-20.0128844051662,10.930284170127,0.));
#516=LINE('',#515,#514);
#517=EDGE_CURVE('E483',#465,#286,#516,.T.);
#518=ORIENTED_EDGE('',*,*,#517,.T.);
#519=EDGE_LOOP('',(#510,#511,#512,#518));
#520=FACE_BOUND('',#519,.T.);
#521=ADVANCED_FACE('F641',(#520),#509,.F.);
#522=CARTESIAN_POINT('',(-20.5128844051662,11.7963095739114,0.));
#523=DIRECTION('',(-0.866025403784438,-0.500000000000001,0.));
#524=DIRECTION('',(0.500000000000001,-0.866025403784438,0.));
#525=AXIS2_PLACEMENT_3D('',#522,#523,#524);
#526=PLANE('',#525);
#527=ORIENTED_EDGE('',*,*,#295,.T.);
#528=ORIENTED_EDGE('',*,*,#517,.F.);
#529=ORIENTED_EDGE('',*,*,#466,.F.);
#530=DIRECTION('',(0.,0.,1.));
#531=VECTOR('',#530,1.);
#532=CARTESIAN_POINT('',(-20.5128844051662,11.7963095739114,0.));
#533=LINE('',#532,#531);
#534=EDGE_CURVE('E485',#457,#294,#533,.T.);
#535=ORIENTED_EDGE('',*,*,#534,.T.);
#536=EDGE_LOOP('',(#527,#528,#529,#535));
#537=FACE_BOUND('',#536,.T.);
#538=ADVANCED_FACE('F678',(#537),#526,.F.);
#539=CARTESIAN_POINT('',(-20.5128844051662,11.7963095739114,0.));
#540=DIRECTION('',(-0.5,0.866025403784439,0.));
#541=DIRECTION('',(-0.866025403784439,-0.5,0.));
#542=AXIS2_PLACEMENT_3D('',#539,#540,#541);
#543=PLANE('',#542);
#544=ORIENTED_EDGE('',*,*,#303,.T.);
#545=ORIENTED_EDGE('',*,*,#534,.F.);
#546=ORIENTED_EDGE('',*,*,#458,.F.);
#547=DIRECTION('',(0.,0.,1.));
#548=VECTOR('',#547,1.);
#549=CARTESIAN_POINT('',(-19.6468590013818,12.2963095739114,0.));
#550=LINE('',#549,#548);
#551=EDGE_CURVE('E487',#449,#302,#550,.T.);
#552=ORIENTED_EDGE('',*,*,#551,.T.);
#553=EDGE_LOOP('',(#544,#545,#546,#552));
#554=FACE_BOUND('',#553,.T.);
#555=ADVANCED_FACE('F674',(#554),#543,.F.);
#556=CARTESIAN_POINT('',(-18.1011792061119,12.6113579506018,0.));
#557=DIRECTION('',(0.,0.,1.));
#558=DIRECTION('',(1.,0.,0.));
#559=AXIS2_PLACEMENT_3D('',#556,#557,#558);
#560=CYLINDRICAL_SURFACE('',#559,1.57746046199599);
#561=ORIENTED_EDGE('',*,*,#312,.T.);
#562=ORIENTED_EDGE('',*,*,#551,.F.);
#563=ORIENTED_EDGE('',*,*,#450,.F.);
#564=DIRECTION('',(0.,0.,1.));
#565=VECTOR('',#564,1.);
#566=CARTESIAN_POINT('',(-18.6011792061119,14.107480107767,0.));
#567=LINE('',#566,#565);
#568=EDGE_CURVE('E489',#440,#311,#567,.T.);
#569=ORIENTED_EDGE('',*,*,#568,.T.);
#570=EDGE_LOOP('',(#561,#562,#563,#569));
#571=FACE_BOUND('',#570,.T.);
#572=ADVANCED_FACE('F670',(#571),#560,.F.);
#573=CARTESIAN_POINT('',(-18.6011792061119,15.107480107767,0.));
#574=DIRECTION('',(-1.,0.,0.));
#575=DIRECTION('',(0.,-1.,0.));
#576=AXIS2_PLACEMENT_3D('',#573,#574,#575);
#577=PLANE('',#576);
#578=ORIENTED_EDGE('',*,*,#320,.T.);
#579=ORIENTED_EDGE('',*,*,#568,.F.);
#580=ORIENTED_EDGE('',*,*,#441,.F.);
#581=DIRECTION('',(0.,0.,1.));
#582=VECTOR('',#581,1.);
#583=CARTESIAN_POINT('',(-18.6011792061119,15.107480107767,0.));
#584=LINE('',#583,#582);
#585=EDGE_CURVE('E491',#432,#319,#584,.T.);
#586=ORIENTED_EDGE('',*,*,#585,.T.);
#587=EDGE_LOOP('',(#578,#579,#580,#586));
#588=FACE_BOUND('',#587,.T.);
#589=ADVANCED_FACE('F666',(#588),#577,.F.);
#590=CARTESIAN_POINT('',(-18.6011792061119,15.107480107767,0.));
#591=DIRECTION('',(0.,1.,0.));
#592=DIRECTION('',(0.,0.,1.));
#593=AXIS2_PLACEMENT_3D('',#590,#591,#592);
#594=PLANE('',#593);
#595=ORIENTED_EDGE('',*,*,#328,.T.);
#596=ORIENTED_EDGE('',*,*,#585,.F.);
#597=ORIENTED_EDGE('',*,*,#433,.F.);
#598=DIRECTION('',(0.,0.,1.));
#599=VECTOR('',#598,1.);
#600=CARTESIAN_POINT('',(-17.6011792061119,15.107480107767,0.));
#601=LINE('',#600,#599);
#602=EDGE_CURVE('E493',#424,#327,#601,.T.);
#603=ORIENTED_EDGE('',*,*,#602,.T.);
#604=EDGE_LOOP('',(#595,#596,#597,#603));
#605=FACE_BOUND('',#604,.T.);
#606=ADVANCED_FACE('F662',(#605),#594,.F.);
#607=CARTESIAN_POINT('',(-17.6011792061119,15.107480107767,0.));
#608=DIRECTION('',(1.,0.,0.));
#609=DIRECTION('',(0.,1.,0.));
#610=AXIS2_PLACEMENT_3D('',#607,#608,#609);
#611=PLANE('',#610);
#612=ORIENTED_EDGE('',*,*,#336,.T.);
#613=ORIENTED_EDGE('',*,*,#602,.F.);
#614=ORIENTED_EDGE('',*,*,#425,.F.);
#615=DIRECTION('',(0.,0.,1.));
#616=VECTOR('',#615,1.);
#617=CARTESIAN_POINT('',(-17.6011792061119,14.107480107767,0.));
#618=LINE('',#617,#616);
#619=EDGE_CURVE('E495',#416,#335,#618,.T.);
#620=ORIENTED_EDGE('',*,*,#619,.T.);
#621=EDGE_LOOP('',(#612,#613,#614,#620));
#622=FACE_BOUND('',#621,.T.);
#623=ADVANCED_FACE('F658',(#622),#611,.F.);
#624=CARTESIAN_POINT('',(-18.1011792061119,12.6113579506018,0.));
#625=DIRECTION('',(0.,0.,1.));
#626=DIRECTION('',(1.,0.,0.));
#627=AXIS2_PLACEMENT_3D('',#624,#625,#626);
#628=CYLINDRICAL_SURFACE('',#627,1.57746046199599);
#629=ORIENTED_EDGE('',*,*,#345,.T.);
#630=ORIENTED_EDGE('',*,*,#619,.F.);
#631=ORIENTED_EDGE('',*,*,#417,.F.);
#632=DIRECTION('',(0.,0.,1.));
#633=VECTOR('',#632,1.);
#634=CARTESIAN_POINT('',(-16.5554994108421,12.2963095739114,0.));
#635=LINE('',#634,#633);
#636=EDGE_CURVE('E497',#407,#344,#635,.T.);
#637=ORIENTED_EDGE('',*,*,#636,.T.);
#638=EDGE_LOOP('',(#629,#630,#631,#637));
#639=FACE_BOUND('',#638,.T.);
#640=ADVANCED_FACE('F654',(#639),#628,.F.);
#641=CARTESIAN_POINT('',(-15.6894740070577,11.7963095739114,0.));
#642=DIRECTION('',(0.499999999999999,0.866025403784439,0.));
#643=DIRECTION('',(-0.866025403784439,0.499999999999999,0.));
#644=AXIS2_PLACEMENT_3D('',#641,#642,#643);
#645=PLANE('',#644);
#646=ORIENTED_EDGE('',*,*,#353,.T.);
#647=ORIENTED_EDGE('',*,*,#636,.F.);
#648=ORIENTED_EDGE('',*,*,#408,.F.);
#649=DIRECTION('',(0.,0.,1.));
#650=VECTOR('',#649,1.);
#651=CARTESIAN_POINT('',(-15.6894740070577,11.7963095739114,0.));
#652=LINE('',#651,#650);
#653=EDGE_CURVE('E499',#399,#352,#652,.T.);
#654=ORIENTED_EDGE('',*,*,#653,.T.);
#655=EDGE_LOOP('',(#646,#647,#648,#654));
#656=FACE_BOUND('',#655,.T.);
#657=ADVANCED_FACE('F650',(#656),#645,.F.);
#658=CARTESIAN_POINT('',(-16.1894740070577,10.930284170127,0.));
#659=DIRECTION('',(0.866025403784441,-0.499999999999995,0.));
#660=DIRECTION('',(0.499999999999995,0.866025403784441,0.));
#661=AXIS2_PLACEMENT_3D('',#658,#659,#660);
#662=PLANE('',#661);
#663=ORIENTED_EDGE('',*,*,#359,.T.);
#664=ORIENTED_EDGE('',*,*,#653,.F.);
#665=ORIENTED_EDGE('',*,*,#400,.F.);
#666=DIRECTION('',(0.,0.,1.));
#667=VECTOR('',#666,1.);
#668=CARTESIAN_POINT('',(-16.1894740070577,10.930284170127,0.));
#669=LINE('',#668,#667);
#670=EDGE_CURVE('E501',#391,#269,#669,.T.);
#671=ORIENTED_EDGE('',*,*,#670,.T.);
#672=EDGE_LOOP('',(#663,#664,#665,#671));
#673=FACE_BOUND('',#672,.T.);
#674=ADVANCED_FACE('F646',(#673),#662,.F.);
#675=CARTESIAN_POINT('',(-16.1894740070577,10.930284170127,0.));
#676=DIRECTION('',(-0.499999999999999,-0.866025403784439,0.));
#677=DIRECTION('',(0.866025403784439,-0.499999999999999,0.));
#678=AXIS2_PLACEMENT_3D('',#675,#676,#677);
#679=PLANE('',#678);
#680=ORIENTED_EDGE('',*,*,#270,.T.);
#681=ORIENTED_EDGE('',*,*,#670,.F.);
#682=ORIENTED_EDGE('',*,*,#392,.F.);
#683=ORIENTED_EDGE('',*,*,#493,.T.);
#684=EDGE_LOOP('',(#680,#681,#682,#683));
#685=FACE_BOUND('',#684,.T.);
#686=ADVANCED_FACE('F643',(#685),#679,.F.);
#687=CARTESIAN_POINT('',(-21.0411792061119,3.07761169240989,-2.13));
#688=DIRECTION('',(0.,0.,-1.));
#689=DIRECTION('',(-1.,0.,0.));
#690=AXIS2_PLACEMENT_3D('',#687,#688,#689);
#691=PLANE('',#690);
#692=CARTESIAN_POINT('',(-20.6411792061119,2.67761169240989,-2.13));
#693=DIRECTION('',(0.,0.,-1.));
#694=DIRECTION('',(-1.,0.,0.));
#695=AXIS2_PLACEMENT_3D('',#692,#693,#694);
#696=CIRCLE('',#695,0.4);
#697=CARTESIAN_POINT('',(-21.0411792061119,2.6776116924099,-2.13));
#698=VERTEX_POINT('',#697);
#699=CARTESIAN_POINT('',(-20.6411792061119,3.07761169240989,-2.13));
#700=VERTEX_POINT('',#699);
#701=EDGE_CURVE('E545',#698,#700,#696,.T.);
#702=ORIENTED_EDGE('',*,*,#701,.T.);
#703=CARTESIAN_POINT('',(-20.641179206112,2.67761169240989,-2.13));
#704=DIRECTION('',(0.,0.,-1.));
#705=DIRECTION('',(-1.,0.,0.));
#706=AXIS2_PLACEMENT_3D('',#703,#704,#705);
#707=CIRCLE('',#706,0.4);
#708=CARTESIAN_POINT('',(-20.2411792061119,2.6776116924099,-2.13));
#709=VERTEX_POINT('',#708);
#710=EDGE_CURVE('E547',#700,#709,#707,.T.);
#711=ORIENTED_EDGE('',*,*,#710,.T.);
#712=CARTESIAN_POINT('',(-20.641179206112,2.6776116924099,-2.13));
#713=DIRECTION('',(0.,0.,-1.));
#714=DIRECTION('',(-1.,0.,0.));
#715=AXIS2_PLACEMENT_3D('',#712,#713,#714);
#716=CIRCLE('',#715,0.4);
#717=CARTESIAN_POINT('',(-20.641179206112,2.2776116924099,-2.13));
#718=VERTEX_POINT('',#717);
#719=EDGE_CURVE('E541',#709,#718,#716,.T.);
#720=ORIENTED_EDGE('',*,*,#719,.T.);
#721=CARTESIAN_POINT('',(-20.6411792061119,2.6776116924099,-2.13));
#722=DIRECTION('',(0.,0.,-1.));
#723=DIRECTION('',(-1.,0.,0.));
#724=AXIS2_PLACEMENT_3D('',#721,#722,#723);
#725=CIRCLE('',#724,0.4);
#726=EDGE_CURVE('E543',#718,#698,#725,.T.);
#727=ORIENTED_EDGE('',*,*,#726,.T.);
#728=EDGE_LOOP('',(#702,#711,#720,#727));
#729=FACE_BOUND('',#728,.T.);
#730=ADVANCED_FACE('F613',(#729),#691,.T.);
#731=CARTESIAN_POINT('',(-18.5011792061119,3.07761169240989,-2.13));
#732=DIRECTION('',(0.,0.,-1.));
#733=DIRECTION('',(-1.,0.,0.));
#734=AXIS2_PLACEMENT_3D('',#731,#732,#733);
#735=PLANE('',#734);
#736=CARTESIAN_POINT('',(-18.1011792061119,2.67761169240989,-2.13));
#737=DIRECTION('',(0.,0.,-1.));
#738=DIRECTION('',(-1.,0.,0.));
#739=AXIS2_PLACEMENT_3D('',#736,#737,#738);
#740=CIRCLE('',#739,0.4);
#741=CARTESIAN_POINT('',(-18.1011792061119,3.07761169240989,-2.13));
#742=VERTEX_POINT('',#741);
#743=CARTESIAN_POINT('',(-17.7011792061119,2.67761169240989,-2.13));
#744=VERTEX_POINT('',#743);
#745=EDGE_CURVE('E536',#742,#744,#740,.T.);
#746=ORIENTED_EDGE('',*,*,#745,.T.);
#747=DIRECTION('',(-1.,0.,0.));
#748=VECTOR('',#747,1.);
#749=CARTESIAN_POINT('',(-18.5011792061119,2.6776116924099,-2.13));
#750=LINE('',#749,#748);
#751=CARTESIAN_POINT('',(-18.5011792061119,2.67761169240989,-2.13));
#752=VERTEX_POINT('',#751);
#753=EDGE_CURVE('E538',#744,#752,#750,.T.);
#754=ORIENTED_EDGE('',*,*,#753,.T.);
#755=CARTESIAN_POINT('',(-18.1011792061119,2.67761169240989,-2.13));
#756=DIRECTION('',(0.,0.,-1.));
#757=DIRECTION('',(-1.,0.,0.));
#758=AXIS2_PLACEMENT_3D('',#755,#756,#757);
#759=CIRCLE('',#758,0.4);
#760=EDGE_CURVE('E534',#752,#742,#759,.T.);
#761=ORIENTED_EDGE('',*,*,#760,.T.);
#762=EDGE_LOOP('',(#746,#754,#761));
#763=FACE_BOUND('',#762,.T.);
#764=ADVANCED_FACE('F604',(#763),#735,.T.);
#765=CARTESIAN_POINT('',(-15.9611792061119,3.07761169240989,-2.13));
#766=DIRECTION('',(0.,0.,-1.));
#767=DIRECTION('',(-1.,0.,0.));
#768=AXIS2_PLACEMENT_3D('',#765,#766,#767);
#769=PLANE('',#768);
#770=CARTESIAN_POINT('',(-15.5611792061119,2.6776116924099,-2.13));
#771=DIRECTION('',(0.,0.,-1.));
#772=DIRECTION('',(-1.,0.,0.));
#773=AXIS2_PLACEMENT_3D('',#770,#771,#772);
#774=CIRCLE('',#773,0.4);
#775=CARTESIAN_POINT('',(-15.1611792061119,2.6776116924099,-2.13));
#776=VERTEX_POINT('',#775);
#777=CARTESIAN_POINT('',(-15.5611792061119,2.27761169240989,-2.13));
#778=VERTEX_POINT('',#777);
#779=EDGE_CURVE('E550',#776,#778,#774,.T.);
#780=ORIENTED_EDGE('',*,*,#779,.T.);
#781=CARTESIAN_POINT('',(-15.5611792061119,2.6776116924099,-2.13));
#782=DIRECTION('',(0.,0.,-1.));
#783=DIRECTION('',(-1.,0.,0.));
#784=AXIS2_PLACEMENT_3D('',#781,#782,#783);
#785=CIRCLE('',#784,0.4);
#786=CARTESIAN_POINT('',(-15.9611792061119,2.67761169240989,-2.13));
#787=VERTEX_POINT('',#786);
#788=EDGE_CURVE('E271',#778,#787,#785,.T.);
#789=ORIENTED_EDGE('',*,*,#788,.T.);
#790=CARTESIAN_POINT('',(-15.5611792061119,2.67761169240989,-2.13));
#791=DIRECTION('',(0.,0.,-1.));
#792=DIRECTION('',(-1.,0.,0.));
#793=AXIS2_PLACEMENT_3D('',#790,#791,#792);
#794=CIRCLE('',#793,0.4);
#795=CARTESIAN_POINT('',(-15.5611792061119,3.07761169240989,-2.13));
#796=VERTEX_POINT('',#795);
#797=EDGE_CURVE('E554',#787,#796,#794,.T.);
#798=ORIENTED_EDGE('',*,*,#797,.T.);
#799=CARTESIAN_POINT('',(-15.5611792061119,2.67761169240989,-2.13));
#800=DIRECTION('',(0.,0.,-1.));
#801=DIRECTION('',(-1.,0.,0.));
#802=AXIS2_PLACEMENT_3D('',#799,#800,#801);
#803=CIRCLE('',#802,0.4);
#804=EDGE_CURVE('E552',#796,#776,#803,.T.);
#805=ORIENTED_EDGE('',*,*,#804,.T.);
#806=EDGE_LOOP('',(#780,#789,#798,#805));
#807=FACE_BOUND('',#806,.T.);
#808=ADVANCED_FACE('F601',(#807),#769,.T.);
#809=CARTESIAN_POINT('',(-18.1011792061119,2.2776116924099,1.27));
#810=DIRECTION('',(0.,1.,0.));
#811=DIRECTION('',(0.,0.,1.));
#812=AXIS2_PLACEMENT_3D('',#809,#810,#811);
#813=CYLINDRICAL_SURFACE('',#812,0.4);
#814=CARTESIAN_POINT('',(-18.1011792061119,2.67761169240989,1.27));
#815=DIRECTION('',(0.,0.707106781186547,0.707106781186547));
#816=DIRECTION('',(0.,0.707106781186547,-0.707106781186547));
#817=AXIS2_PLACEMENT_3D('',#814,#815,#816);
#818=ELLIPSE('',#817,0.565685424949238,0.4);
#819=CARTESIAN_POINT('',(-18.1011792061119,3.07761169240989,0.87));
#820=VERTEX_POINT('',#819);
#821=CARTESIAN_POINT('',(-17.7011792061119,2.6776116924099,1.27));
#822=VERTEX_POINT('',#821);
#823=EDGE_CURVE('E406',#820,#822,#818,.F.);
#824=ORIENTED_EDGE('',*,*,#823,.F.);
#825=DIRECTION('',(0.,1.,0.));
#826=VECTOR('',#825,1.);
#827=CARTESIAN_POINT('',(-18.1011792061119,2.2776116924099,0.87));
#828=LINE('',#827,#826);
#829=EDGE_CURVE('E398',#88,#820,#828,.F.);
#830=ORIENTED_EDGE('',*,*,#829,.F.);
#831=ORIENTED_EDGE('',*,*,#89,.F.);
#832=DIRECTION('',(0.,1.,0.));
#833=VECTOR('',#832,1.);
#834=CARTESIAN_POINT('',(-17.7011792061119,2.2776116924099,1.27));
#835=LINE('',#834,#833);
#836=EDGE_CURVE('E395',#822,#79,#835,.T.);
#837=ORIENTED_EDGE('',*,*,#836,.F.);
#838=EDGE_LOOP('',(#824,#830,#831,#837));
#839=FACE_BOUND('',#838,.T.);
#840=ADVANCED_FACE('F603',(#839),#813,.T.);
#841=CARTESIAN_POINT('',(-18.1011792061119,2.67761169240989,1.67));
#842=DIRECTION('',(0.,0.,1.));
#843=DIRECTION('',(1.,0.,0.));
#844=AXIS2_PLACEMENT_3D('',#841,#842,#843);
#845=CYLINDRICAL_SURFACE('',#844,0.4);
#846=DIRECTION('',(0.,0.,1.));
#847=VECTOR('',#846,1.);
#848=CARTESIAN_POINT('',(-17.7011792061119,2.67761169240989,1.67));
#849=LINE('',#848,#847);
#850=EDGE_CURVE('E392',#744,#822,#849,.T.);
#851=ORIENTED_EDGE('',*,*,#850,.F.);
#852=ORIENTED_EDGE('',*,*,#745,.F.);
#853=DIRECTION('',(0.,0.,1.));
#854=VECTOR('',#853,1.);
#855=CARTESIAN_POINT('',(-18.1011792061119,3.07761169240989,-2.13));
#856=LINE('',#855,#854);
#857=EDGE_CURVE('E403',#820,#742,#856,.F.);
#858=ORIENTED_EDGE('',*,*,#857,.F.);
#859=ORIENTED_EDGE('',*,*,#823,.T.);
#860=EDGE_LOOP('',(#851,#852,#858,#859));
#861=FACE_BOUND('',#860,.T.);
#862=ADVANCED_FACE('F610',(#861),#845,.T.);
#863=CARTESIAN_POINT('',(-18.5011792061119,2.6776116924099,-1.73));
#864=DIRECTION('',(-1.,0.,0.));
#865=DIRECTION('',(0.,0.,1.));
#866=AXIS2_PLACEMENT_3D('',#863,#864,#865);
#867=CYLINDRICAL_SURFACE('',#866,0.4);
#868=CARTESIAN_POINT('',(-18.1011792061119,2.6776116924099,-1.73));
#869=DIRECTION('',(-0.707106781186548,0.,0.707106781186547));
#870=DIRECTION('',(0.707106781186547,0.,0.707106781186548));
#871=AXIS2_PLACEMENT_3D('',#868,#869,#870);
#872=ELLIPSE('',#871,0.565685424949238,0.4);
#873=CARTESIAN_POINT('',(-18.1011792061119,2.2776116924099,-1.73));
#874=VERTEX_POINT('',#873);
#875=EDGE_CURVE('E384',#752,#874,#872,.T.);
#876=ORIENTED_EDGE('',*,*,#875,.F.);
#877=ORIENTED_EDGE('',*,*,#753,.F.);
#878=CARTESIAN_POINT('',(-18.1011792061119,2.6776116924099,-1.73));
#879=DIRECTION('',(-0.707106781186547,0.,-0.707106781186548));
#880=DIRECTION('',(-0.707106781186548,0.,0.707106781186547));
#881=AXIS2_PLACEMENT_3D('',#878,#879,#880);
#882=ELLIPSE('',#881,0.565685424949238,0.4);
#883=EDGE_CURVE('E389',#874,#744,#882,.F.);
#884=ORIENTED_EDGE('',*,*,#883,.F.);
#885=EDGE_LOOP('',(#876,#877,#884));
#886=FACE_BOUND('',#885,.T.);
#887=ADVANCED_FACE('F777',(#886),#867,.T.);
#888=CARTESIAN_POINT('',(-18.1011792061119,2.67761169240989,-2.13));
#889=DIRECTION('',(0.,0.,1.));
#890=DIRECTION('',(1.,0.,0.));
#891=AXIS2_PLACEMENT_3D('',#888,#889,#890);
#892=CYLINDRICAL_SURFACE('',#891,0.4);
#893=CARTESIAN_POINT('',(-18.1011792061119,2.67761169240989,1.27));
#894=DIRECTION('',(0.,0.707106781186547,0.707106781186547));
#895=DIRECTION('',(0.,-0.707106781186547,0.707106781186547));
#896=AXIS2_PLACEMENT_3D('',#893,#894,#895);
#897=ELLIPSE('',#896,0.565685424949238,0.4);
#898=CARTESIAN_POINT('',(-18.5011792061119,2.6776116924099,1.27));
#899=VERTEX_POINT('',#898);
#900=EDGE_CURVE('E401',#820,#899,#897,.T.);
#901=ORIENTED_EDGE('',*,*,#900,.F.);
#902=ORIENTED_EDGE('',*,*,#857,.T.);
#903=ORIENTED_EDGE('',*,*,#760,.F.);
#904=DIRECTION('',(0.,0.,1.));
#905=VECTOR('',#904,1.);
#906=CARTESIAN_POINT('',(-18.5011792061119,2.67761169240989,1.67));
#907=LINE('',#906,#905);
#908=EDGE_CURVE('E382',#899,#752,#907,.F.);
#909=ORIENTED_EDGE('',*,*,#908,.F.);
#910=EDGE_LOOP('',(#901,#902,#903,#909));
#911=FACE_BOUND('',#910,.T.);
#912=ADVANCED_FACE('F773',(#911),#892,.T.);
#913=CARTESIAN_POINT('',(-18.1011792061119,2.2776116924099,1.27));
#914=DIRECTION('',(0.,1.,0.));
#915=DIRECTION('',(0.,0.,1.));
#916=AXIS2_PLACEMENT_3D('',#913,#914,#915);
#917=CYLINDRICAL_SURFACE('',#916,0.4);
#918=ORIENTED_EDGE('',*,*,#829,.T.);
#919=ORIENTED_EDGE('',*,*,#900,.T.);
#920=DIRECTION('',(0.,1.,0.));
#921=VECTOR('',#920,1.);
#922=CARTESIAN_POINT('',(-18.5011792061119,2.2776116924099,1.27));
#923=LINE('',#922,#921);
#924=EDGE_CURVE('E379',#68,#899,#923,.F.);
#925=ORIENTED_EDGE('',*,*,#924,.F.);
#926=ORIENTED_EDGE('',*,*,#96,.F.);
#927=EDGE_LOOP('',(#918,#919,#925,#926));
#928=FACE_BOUND('',#927,.T.);
#929=ADVANCED_FACE('F769',(#928),#917,.T.);
#930=CARTESIAN_POINT('',(-18.1011792061119,2.2776116924099,1.27));
#931=DIRECTION('',(0.,1.,0.));
#932=DIRECTION('',(0.,0.,1.));
#933=AXIS2_PLACEMENT_3D('',#930,#931,#932);
#934=CYLINDRICAL_SURFACE('',#933,0.4);
#935=ORIENTED_EDGE('',*,*,#836,.T.);
#936=ORIENTED_EDGE('',*,*,#80,.F.);
#937=DIRECTION('',(0.,1.,0.));
#938=VECTOR('',#937,1.);
#939=CARTESIAN_POINT('',(-18.1011792061119,2.2776116924099,1.67));
#940=LINE('',#939,#938);
#941=CARTESIAN_POINT('',(-18.1011792061119,2.6776116924099,1.67));
#942=VERTEX_POINT('',#941);
#943=EDGE_CURVE('E376',#942,#70,#940,.T.);
#944=ORIENTED_EDGE('',*,*,#943,.F.);
#945=CARTESIAN_POINT('',(-18.1011792061119,2.6776116924099,1.27));
#946=DIRECTION('',(0.,-1.,0.));
#947=DIRECTION('',(0.,0.,-1.));
#948=AXIS2_PLACEMENT_3D('',#945,#946,#947);
#949=CIRCLE('',#948,0.4);
#950=EDGE_CURVE('E373',#822,#942,#949,.T.);
#951=ORIENTED_EDGE('',*,*,#950,.F.);
#952=EDGE_LOOP('',(#935,#936,#944,#951));
#953=FACE_BOUND('',#952,.T.);
#954=ADVANCED_FACE('F765',(#953),#934,.T.);
#955=CARTESIAN_POINT('',(-18.1011792061119,2.6776116924099,0.87));
#956=DIRECTION('',(0.,0.,-1.));
#957=DIRECTION('',(-1.,0.,0.));
#958=AXIS2_PLACEMENT_3D('',#955,#956,#957);
#959=CYLINDRICAL_SURFACE('',#958,0.4);
#960=DIRECTION('',(0.,0.,1.));
#961=VECTOR('',#960,1.);
#962=CARTESIAN_POINT('',(-18.1011792061119,2.2776116924099,1.67));
#963=LINE('',#962,#961);
#964=CARTESIAN_POINT('',(-18.1011792061119,2.2776116924099,1.27));
#965=VERTEX_POINT('',#964);
#966=EDGE_CURVE('E387',#874,#965,#963,.T.);
#967=ORIENTED_EDGE('',*,*,#966,.F.);
#968=ORIENTED_EDGE('',*,*,#883,.T.);
#969=ORIENTED_EDGE('',*,*,#850,.T.);
#970=CARTESIAN_POINT('',(-18.1011792061119,2.6776116924099,1.27));
#971=DIRECTION('',(0.,0.,1.));
#972=DIRECTION('',(1.,0.,0.));
#973=AXIS2_PLACEMENT_3D('',#970,#971,#972);
#974=CIRCLE('',#973,0.4);
#975=EDGE_CURVE('E370',#965,#822,#974,.T.);
#976=ORIENTED_EDGE('',*,*,#975,.F.);
#977=EDGE_LOOP('',(#967,#968,#969,#976));
#978=FACE_BOUND('',#977,.T.);
#979=ADVANCED_FACE('F761',(#978),#959,.T.);
#980=CARTESIAN_POINT('',(-18.1011792061119,2.6776116924099,0.87));
#981=DIRECTION('',(0.,0.,1.));
#982=DIRECTION('',(1.,0.,0.));
#983=AXIS2_PLACEMENT_3D('',#980,#981,#982);
#984=CYLINDRICAL_SURFACE('',#983,0.4);
#985=ORIENTED_EDGE('',*,*,#875,.T.);
#986=ORIENTED_EDGE('',*,*,#966,.T.);
#987=CARTESIAN_POINT('',(-18.1011792061119,2.6776116924099,1.27));
#988=DIRECTION('',(0.,0.,1.));
#989=DIRECTION('',(1.,0.,0.));
#990=AXIS2_PLACEMENT_3D('',#987,#988,#989);
#991=CIRCLE('',#990,0.4);
#992=EDGE_CURVE('E367',#899,#965,#991,.T.);
#993=ORIENTED_EDGE('',*,*,#992,.F.);
#994=ORIENTED_EDGE('',*,*,#908,.T.);
#995=EDGE_LOOP('',(#985,#986,#993,#994));
#996=FACE_BOUND('',#995,.T.);
#997=ADVANCED_FACE('F757',(#996),#984,.T.);
#998=CARTESIAN_POINT('',(-18.1011792061119,2.2776116924099,1.27));
#999=DIRECTION('',(0.,1.,0.));
#1000=DIRECTION('',(0.,0.,1.));
#1001=AXIS2_PLACEMENT_3D('',#998,#999,#1000);
#1002=CYLINDRICAL_SURFACE('',#1001,0.4);
#1003=ORIENTED_EDGE('',*,*,#71,.F.);
#1004=ORIENTED_EDGE('',*,*,#924,.T.);
#1005=CARTESIAN_POINT('',(-18.1011792061119,2.6776116924099,1.27));
#1006=DIRECTION('',(0.,-1.,0.));
#1007=DIRECTION('',(0.,0.,-1.));
#1008=AXIS2_PLACEMENT_3D('',#1005,#1006,#1007);
#1009=CIRCLE('',#1008,0.4);
#1010=EDGE_CURVE('E364',#942,#899,#1009,.T.);
#1011=ORIENTED_EDGE('',*,*,#1010,.F.);
#1012=ORIENTED_EDGE('',*,*,#943,.T.);
#1013=EDGE_LOOP('',(#1003,#1004,#1011,#1012));
#1014=FACE_BOUND('',#1013,.T.);
#1015=ADVANCED_FACE('F753',(#1014),#1002,.T.);
#1016=CARTESIAN_POINT('',(-18.1011792061119,2.6776116924099,1.27));
#1017=DIRECTION('',(0.,0.,1.));
#1018=DIRECTION('',(1.,0.,0.));
#1019=AXIS2_PLACEMENT_3D('',#1016,#1017,#1018);
#1020=SPHERICAL_SURFACE('',#1019,0.4);
#1021=ORIENTED_EDGE('',*,*,#975,.T.);
#1022=ORIENTED_EDGE('',*,*,#950,.T.);
#1023=CARTESIAN_POINT('',(-18.1011792061119,2.6776116924099,1.27));
#1024=DIRECTION('',(1.,0.,0.));
#1025=DIRECTION('',(0.,0.,-1.));
#1026=AXIS2_PLACEMENT_3D('',#1023,#1024,#1025);
#1027=CIRCLE('',#1026,0.4);
#1028=EDGE_CURVE('E361',#965,#942,#1027,.F.);
#1029=ORIENTED_EDGE('',*,*,#1028,.F.);
#1030=EDGE_LOOP('',(#1021,#1022,#1029));
#1031=FACE_BOUND('',#1030,.T.);
#1032=ADVANCED_FACE('F749',(#1031),#1020,.T.);
#1033=CARTESIAN_POINT('',(-18.1011792061119,2.6776116924099,1.27));
#1034=DIRECTION('',(0.,0.,1.));
#1035=DIRECTION('',(1.,0.,0.));
#1036=AXIS2_PLACEMENT_3D('',#1033,#1034,#1035);
#1037=SPHERICAL_SURFACE('',#1036,0.4);
#1038=ORIENTED_EDGE('',*,*,#1010,.T.);
#1039=ORIENTED_EDGE('',*,*,#992,.T.);
#1040=ORIENTED_EDGE('',*,*,#1028,.T.);
#1041=EDGE_LOOP('',(#1038,#1039,#1040));
#1042=FACE_BOUND('',#1041,.T.);
#1043=ADVANCED_FACE('F746',(#1042),#1037,.T.);
#1044=CARTESIAN_POINT('',(-20.6411792061119,2.6776116924099,0.87));
#1045=DIRECTION('',(0.,0.,1.));
#1046=DIRECTION('',(1.,0.,0.));
#1047=AXIS2_PLACEMENT_3D('',#1044,#1045,#1046);
#1048=CYLINDRICAL_SURFACE('',#1047,0.4);
#1049=DIRECTION('',(0.,0.,-1.));
#1050=VECTOR('',#1049,1.);
#1051=CARTESIAN_POINT('',(-20.6411792061119,2.2776116924099,-2.13));
#1052=LINE('',#1051,#1050);
#1053=CARTESIAN_POINT('',(-20.6411792061119,2.2776116924099,1.27));
#1054=VERTEX_POINT('',#1053);
#1055=EDGE_CURVE('E352',#1054,#718,#1052,.T.);
#1056=ORIENTED_EDGE('',*,*,#1055,.F.);
#1057=CARTESIAN_POINT('',(-20.6411792061119,2.6776116924099,1.27));
#1058=DIRECTION('',(0.,0.,1.));
#1059=DIRECTION('',(1.,0.,0.));
#1060=AXIS2_PLACEMENT_3D('',#1057,#1058,#1059);
#1061=CIRCLE('',#1060,0.4);
#1062=CARTESIAN_POINT('',(-21.0411792061119,2.67761169240989,1.27));
#1063=VERTEX_POINT('',#1062);
#1064=EDGE_CURVE('E358',#1063,#1054,#1061,.T.);
#1065=ORIENTED_EDGE('',*,*,#1064,.F.);
#1066=DIRECTION('',(0.,0.,-1.));
#1067=VECTOR('',#1066,1.);
#1068=CARTESIAN_POINT('',(-21.0411792061119,2.6776116924099,1.67));
#1069=LINE('',#1068,#1067);
#1070=EDGE_CURVE('E355',#698,#1063,#1069,.F.);
#1071=ORIENTED_EDGE('',*,*,#1070,.F.);
#1072=ORIENTED_EDGE('',*,*,#726,.F.);
#1073=EDGE_LOOP('',(#1056,#1065,#1071,#1072));
#1074=FACE_BOUND('',#1073,.T.);
#1075=ADVANCED_FACE('F708',(#1074),#1048,.T.);
#1076=CARTESIAN_POINT('',(-20.6411792061119,2.6776116924099,1.27));
#1077=DIRECTION('',(0.,0.,1.));
#1078=DIRECTION('',(1.,0.,0.));
#1079=AXIS2_PLACEMENT_3D('',#1076,#1077,#1078);
#1080=SPHERICAL_SURFACE('',#1079,0.4);
#1081=ORIENTED_EDGE('',*,*,#1064,.T.);
#1082=CARTESIAN_POINT('',(-20.6411792061119,2.6776116924099,1.27));
#1083=DIRECTION('',(1.,0.,0.));
#1084=DIRECTION('',(0.,1.,0.));
#1085=AXIS2_PLACEMENT_3D('',#1082,#1083,#1084);
#1086=CIRCLE('',#1085,0.4);
#1087=CARTESIAN_POINT('',(-20.6411792061119,2.6776116924099,1.67));
#1088=VERTEX_POINT('',#1087);
#1089=EDGE_CURVE('E348',#1088,#1054,#1086,.T.);
#1090=ORIENTED_EDGE('',*,*,#1089,.F.);
#1091=CARTESIAN_POINT('',(-20.6411792061119,2.6776116924099,1.27));
#1092=DIRECTION('',(0.,-1.,0.));
#1093=DIRECTION('',(0.,0.,-1.));
#1094=AXIS2_PLACEMENT_3D('',#1091,#1092,#1093);
#1095=CIRCLE('',#1094,0.4);
#1096=EDGE_CURVE('E345',#1063,#1088,#1095,.F.);
#1097=ORIENTED_EDGE('',*,*,#1096,.F.);
#1098=EDGE_LOOP('',(#1081,#1090,#1097));
#1099=FACE_BOUND('',#1098,.T.);
#1100=ADVANCED_FACE('F712',(#1099),#1080,.T.);
#1101=CARTESIAN_POINT('',(-20.6411792061119,2.67761169240989,-2.13));
#1102=DIRECTION('',(0.,0.,1.));
#1103=DIRECTION('',(1.,0.,0.));
#1104=AXIS2_PLACEMENT_3D('',#1101,#1102,#1103);
#1105=CYLINDRICAL_SURFACE('',#1104,0.4);
#1106=ORIENTED_EDGE('',*,*,#701,.F.);
#1107=ORIENTED_EDGE('',*,*,#1070,.T.);
#1108=CARTESIAN_POINT('',(-20.6411792061119,2.67761169240989,1.27));
#1109=DIRECTION('',(0.,0.707106781186547,0.707106781186547));
#1110=DIRECTION('',(0.,0.707106781186547,-0.707106781186547));
#1111=AXIS2_PLACEMENT_3D('',#1108,#1109,#1110);
#1112=ELLIPSE('',#1111,0.565685424949238,0.4);
#1113=CARTESIAN_POINT('',(-20.6411792061119,3.07761169240989,0.87));
#1114=VERTEX_POINT('',#1113);
#1115=EDGE_CURVE('E339',#1114,#1063,#1112,.T.);
#1116=ORIENTED_EDGE('',*,*,#1115,.F.);
#1117=DIRECTION('',(0.,0.,1.));
#1118=VECTOR('',#1117,1.);
#1119=CARTESIAN_POINT('',(-20.6411792061119,3.07761169240989,-2.13));
#1120=LINE('',#1119,#1118);
#1121=EDGE_CURVE('E336',#700,#1114,#1120,.T.);
#1122=ORIENTED_EDGE('',*,*,#1121,.F.);
#1123=EDGE_LOOP('',(#1106,#1107,#1116,#1122));
#1124=FACE_BOUND('',#1123,.T.);
#1125=ADVANCED_FACE('F696',(#1124),#1105,.T.);
#1126=CARTESIAN_POINT('',(-20.6411792061119,2.6776116924099,0.869999999999998));
#1127=DIRECTION('',(0.,0.,-1.));
#1128=DIRECTION('',(-1.,0.,0.));
#1129=AXIS2_PLACEMENT_3D('',#1126,#1127,#1128);
#1130=CYLINDRICAL_SURFACE('',#1129,0.4);
#1131=CARTESIAN_POINT('',(-20.6411792061119,2.6776116924099,1.27));
#1132=DIRECTION('',(0.,0.,1.));
#1133=DIRECTION('',(1.,0.,0.));
#1134=AXIS2_PLACEMENT_3D('',#1131,#1132,#1133);
#1135=CIRCLE('',#1134,0.4);
#1136=CARTESIAN_POINT('',(-20.2411792061119,2.67761169240989,1.27));
#1137=VERTEX_POINT('',#1136);
#1138=EDGE_CURVE('E350',#1054,#1137,#1135,.T.);
#1139=ORIENTED_EDGE('',*,*,#1138,.F.);
#1140=ORIENTED_EDGE('',*,*,#1055,.T.);
#1141=ORIENTED_EDGE('',*,*,#719,.F.);
#1142=DIRECTION('',(0.,0.,1.));
#1143=VECTOR('',#1142,1.);
#1144=CARTESIAN_POINT('',(-20.241179206112,2.6776116924099,-2.13));
#1145=LINE('',#1144,#1143);
#1146=EDGE_CURVE('E334',#1137,#709,#1145,.F.);
#1147=ORIENTED_EDGE('',*,*,#1146,.F.);
#1148=EDGE_LOOP('',(#1139,#1140,#1141,#1147));
#1149=FACE_BOUND('',#1148,.T.);
#1150=ADVANCED_FACE('F705',(#1149),#1130,.T.);
#1151=CARTESIAN_POINT('',(-20.6411792061119,2.6776116924099,1.27));
#1152=DIRECTION('',(0.,0.,1.));
#1153=DIRECTION('',(1.,0.,0.));
#1154=AXIS2_PLACEMENT_3D('',#1151,#1152,#1153);
#1155=SPHERICAL_SURFACE('',#1154,0.4);
#1156=ORIENTED_EDGE('',*,*,#1089,.T.);
#1157=ORIENTED_EDGE('',*,*,#1138,.T.);
#1158=CARTESIAN_POINT('',(-20.6411792061119,2.6776116924099,1.27));
#1159=DIRECTION('',(0.,-1.,0.));
#1160=DIRECTION('',(0.,0.,-1.));
#1161=AXIS2_PLACEMENT_3D('',#1158,#1159,#1160);
#1162=CIRCLE('',#1161,0.4);
#1163=EDGE_CURVE('E331',#1088,#1137,#1162,.F.);
#1164=ORIENTED_EDGE('',*,*,#1163,.F.);
#1165=EDGE_LOOP('',(#1156,#1157,#1164));
#1166=FACE_BOUND('',#1165,.T.);
#1167=ADVANCED_FACE('F729',(#1166),#1155,.T.);
#1168=CARTESIAN_POINT('',(-20.6411792061119,2.2776116924099,1.27));
#1169=DIRECTION('',(0.,1.,0.));
#1170=DIRECTION('',(0.,0.,1.));
#1171=AXIS2_PLACEMENT_3D('',#1168,#1169,#1170);
#1172=CYLINDRICAL_SURFACE('',#1171,0.4);
#1173=DIRECTION('',(0.,1.,0.));
#1174=VECTOR('',#1173,1.);
#1175=CARTESIAN_POINT('',(-20.6411792061119,2.2776116924099,1.67));
#1176=LINE('',#1175,#1174);
#1177=EDGE_CURVE('E328',#108,#1088,#1176,.F.);
#1178=ORIENTED_EDGE('',*,*,#1177,.F.);
#1179=ORIENTED_EDGE('',*,*,#109,.F.);
#1180=DIRECTION('',(0.,1.,0.));
#1181=VECTOR('',#1180,1.);
#1182=CARTESIAN_POINT('',(-21.0411792061119,2.2776116924099,1.27));
#1183=LINE('',#1182,#1181);
#1184=EDGE_CURVE('E342',#1063,#106,#1183,.T.);
#1185=ORIENTED_EDGE('',*,*,#1184,.F.);
#1186=ORIENTED_EDGE('',*,*,#1096,.T.);
#1187=EDGE_LOOP('',(#1178,#1179,#1185,#1186));
#1188=FACE_BOUND('',#1187,.T.);
#1189=ADVANCED_FACE('F717',(#1188),#1172,.T.);
#1190=CARTESIAN_POINT('',(-20.6411792061119,2.2776116924099,1.27));
#1191=DIRECTION('',(0.,1.,0.));
#1192=DIRECTION('',(0.,0.,1.));
#1193=AXIS2_PLACEMENT_3D('',#1190,#1191,#1192);
#1194=CYLINDRICAL_SURFACE('',#1193,0.4);
#1195=ORIENTED_EDGE('',*,*,#1184,.T.);
#1196=ORIENTED_EDGE('',*,*,#134,.F.);
#1197=DIRECTION('',(0.,1.,0.));
#1198=VECTOR('',#1197,1.);
#1199=CARTESIAN_POINT('',(-20.6411792061119,2.2776116924099,0.87));
#1200=LINE('',#1199,#1198);
#1201=EDGE_CURVE('E326',#1114,#126,#1200,.T.);
#1202=ORIENTED_EDGE('',*,*,#1201,.F.);
#1203=ORIENTED_EDGE('',*,*,#1115,.T.);
#1204=EDGE_LOOP('',(#1195,#1196,#1202,#1203));
#1205=FACE_BOUND('',#1204,.T.);
#1206=ADVANCED_FACE('F720',(#1205),#1194,.T.);
#1207=CARTESIAN_POINT('',(-20.6411792061119,2.67761169240989,1.67));
#1208=DIRECTION('',(0.,0.,1.));
#1209=DIRECTION('',(1.,0.,0.));
#1210=AXIS2_PLACEMENT_3D('',#1207,#1208,#1209);
#1211=CYLINDRICAL_SURFACE('',#1210,0.4);
#1212=ORIENTED_EDGE('',*,*,#710,.F.);
#1213=ORIENTED_EDGE('',*,*,#1121,.T.);
#1214=CARTESIAN_POINT('',(-20.6411792061119,2.67761169240989,1.27));
#1215=DIRECTION('',(0.,0.707106781186547,0.707106781186547));
#1216=DIRECTION('',(0.,0.707106781186547,-0.707106781186547));
#1217=AXIS2_PLACEMENT_3D('',#1214,#1215,#1216);
#1218=ELLIPSE('',#1217,0.565685424949238,0.4);
#1219=EDGE_CURVE('E323',#1137,#1114,#1218,.T.);
#1220=ORIENTED_EDGE('',*,*,#1219,.F.);
#1221=ORIENTED_EDGE('',*,*,#1146,.T.);
#1222=EDGE_LOOP('',(#1212,#1213,#1220,#1221));
#1223=FACE_BOUND('',#1222,.T.);
#1224=ADVANCED_FACE('F700',(#1223),#1211,.T.);
#1225=CARTESIAN_POINT('',(-20.6411792061119,2.2776116924099,1.27));
#1226=DIRECTION('',(0.,1.,0.));
#1227=DIRECTION('',(0.,0.,1.));
#1228=AXIS2_PLACEMENT_3D('',#1225,#1226,#1227);
#1229=CYLINDRICAL_SURFACE('',#1228,0.4);
#1230=ORIENTED_EDGE('',*,*,#1177,.T.);
#1231=ORIENTED_EDGE('',*,*,#1163,.T.);
#1232=DIRECTION('',(0.,1.,0.));
#1233=VECTOR('',#1232,1.);
#1234=CARTESIAN_POINT('',(-20.2411792061119,2.2776116924099,1.27));
#1235=LINE('',#1234,#1233);
#1236=EDGE_CURVE('E320',#117,#1137,#1235,.F.);
#1237=ORIENTED_EDGE('',*,*,#1236,.F.);
#1238=ORIENTED_EDGE('',*,*,#118,.F.);
#1239=EDGE_LOOP('',(#1230,#1231,#1237,#1238));
#1240=FACE_BOUND('',#1239,.T.);
#1241=ADVANCED_FACE('F727',(#1240),#1229,.T.);
#1242=CARTESIAN_POINT('',(-20.6411792061119,2.2776116924099,1.27));
#1243=DIRECTION('',(0.,1.,0.));
#1244=DIRECTION('',(0.,0.,1.));
#1245=AXIS2_PLACEMENT_3D('',#1242,#1243,#1244);
#1246=CYLINDRICAL_SURFACE('',#1245,0.4);
#1247=ORIENTED_EDGE('',*,*,#1219,.T.);
#1248=ORIENTED_EDGE('',*,*,#1201,.T.);
#1249=ORIENTED_EDGE('',*,*,#127,.F.);
#1250=ORIENTED_EDGE('',*,*,#1236,.T.);
#1251=EDGE_LOOP('',(#1247,#1248,#1249,#1250));
#1252=FACE_BOUND('',#1251,.T.);
#1253=ADVANCED_FACE('F723',(#1252),#1246,.T.);
#1254=CARTESIAN_POINT('',(-15.5611792061119,2.2776116924099,1.27));
#1255=DIRECTION('',(0.,1.,0.));
#1256=DIRECTION('',(0.,0.,1.));
#1257=AXIS2_PLACEMENT_3D('',#1254,#1255,#1256);
#1258=CYLINDRICAL_SURFACE('',#1257,0.4);
#1259=CARTESIAN_POINT('',(-15.5611792061119,2.67761169240989,1.27));
#1260=DIRECTION('',(0.,0.707106781186547,0.707106781186547));
#1261=DIRECTION('',(0.,0.707106781186547,-0.707106781186547));
#1262=AXIS2_PLACEMENT_3D('',#1259,#1260,#1261);
#1263=ELLIPSE('',#1262,0.565685424949238,0.4);
#1264=CARTESIAN_POINT('',(-15.5611792061119,3.07761169240989,0.870000000000001));
#1265=VERTEX_POINT('',#1264);
#1266=CARTESIAN_POINT('',(-15.1611792061119,2.6776116924099,1.27));
#1267=VERTEX_POINT('',#1266);
#1268=EDGE_CURVE('E318',#1265,#1267,#1263,.F.);
#1269=ORIENTED_EDGE('',*,*,#1268,.F.);
#1270=DIRECTION('',(0.,1.,0.));
#1271=VECTOR('',#1270,1.);
#1272=CARTESIAN_POINT('',(-15.5611792061119,2.2776116924099,0.87));
#1273=LINE('',#1272,#1271);
#1274=EDGE_CURVE('E310',#41,#1265,#1273,.F.);
#1275=ORIENTED_EDGE('',*,*,#1274,.F.);
#1276=ORIENTED_EDGE('',*,*,#42,.F.);
#1277=DIRECTION('',(0.,1.,0.));
#1278=VECTOR('',#1277,1.);
#1279=CARTESIAN_POINT('',(-15.1611792061119,2.2776116924099,1.27));
#1280=LINE('',#1279,#1278);
#1281=EDGE_CURVE('E307',#1267,#32,#1280,.T.);
#1282=ORIENTED_EDGE('',*,*,#1281,.F.);
#1283=EDGE_LOOP('',(#1269,#1275,#1276,#1282));
#1284=FACE_BOUND('',#1283,.T.);
#1285=ADVANCED_FACE('F592',(#1284),#1258,.T.);
#1286=CARTESIAN_POINT('',(-15.5611792061119,2.67761169240989,1.67));
#1287=DIRECTION('',(0.,0.,1.));
#1288=DIRECTION('',(1.,0.,0.));
#1289=AXIS2_PLACEMENT_3D('',#1286,#1287,#1288);
#1290=CYLINDRICAL_SURFACE('',#1289,0.4);
#1291=DIRECTION('',(0.,0.,1.));
#1292=VECTOR('',#1291,1.);
#1293=CARTESIAN_POINT('',(-15.1611792061119,2.67761169240989,1.67));
#1294=LINE('',#1293,#1292);
#1295=EDGE_CURVE('E274',#776,#1267,#1294,.T.);
#1296=ORIENTED_EDGE('',*,*,#1295,.F.);
#1297=ORIENTED_EDGE('',*,*,#804,.F.);
#1298=DIRECTION('',(0.,0.,1.));
#1299=VECTOR('',#1298,1.);
#1300=CARTESIAN_POINT('',(-15.5611792061119,3.07761169240989,-2.13));
#1301=LINE('',#1300,#1299);
#1302=EDGE_CURVE('E315',#1265,#796,#1301,.F.);
#1303=ORIENTED_EDGE('',*,*,#1302,.F.);
#1304=ORIENTED_EDGE('',*,*,#1268,.T.);
#1305=EDGE_LOOP('',(#1296,#1297,#1303,#1304));
#1306=FACE_BOUND('',#1305,.T.);
#1307=ADVANCED_FACE('F596',(#1306),#1290,.T.);
#1308=CARTESIAN_POINT('',(-15.5611792061119,2.67761169240989,-2.13));
#1309=DIRECTION('',(0.,0.,1.));
#1310=DIRECTION('',(1.,0.,0.));
#1311=AXIS2_PLACEMENT_3D('',#1308,#1309,#1310);
#1312=CYLINDRICAL_SURFACE('',#1311,0.4);
#1313=CARTESIAN_POINT('',(-15.5611792061119,2.67761169240989,1.27));
#1314=DIRECTION('',(0.,0.707106781186547,0.707106781186547));
#1315=DIRECTION('',(0.,-0.707106781186547,0.707106781186547));
#1316=AXIS2_PLACEMENT_3D('',#1313,#1314,#1315);
#1317=ELLIPSE('',#1316,0.565685424949238,0.4);
#1318=CARTESIAN_POINT('',(-15.9611792061119,2.6776116924099,1.27));
#1319=VERTEX_POINT('',#1318);
#1320=EDGE_CURVE('E313',#1265,#1319,#1317,.T.);
#1321=ORIENTED_EDGE('',*,*,#1320,.F.);
#1322=ORIENTED_EDGE('',*,*,#1302,.T.);
#1323=ORIENTED_EDGE('',*,*,#797,.F.);
#1324=DIRECTION('',(0.,0.,1.));
#1325=VECTOR('',#1324,1.);
#1326=CARTESIAN_POINT('',(-15.9611792061119,2.67761169240989,1.67));
#1327=LINE('',#1326,#1325);
#1328=EDGE_CURVE('E275',#1319,#787,#1327,.F.);
#1329=ORIENTED_EDGE('',*,*,#1328,.F.);
#1330=EDGE_LOOP('',(#1321,#1322,#1323,#1329));
#1331=FACE_BOUND('',#1330,.T.);
#1332=ADVANCED_FACE('F599',(#1331),#1312,.T.);
#1333=CARTESIAN_POINT('',(-15.5611792061119,2.2776116924099,1.27));
#1334=DIRECTION('',(0.,1.,0.));
#1335=DIRECTION('',(0.,0.,1.));
#1336=AXIS2_PLACEMENT_3D('',#1333,#1334,#1335);
#1337=CYLINDRICAL_SURFACE('',#1336,0.4);
#1338=ORIENTED_EDGE('',*,*,#1274,.T.);
#1339=ORIENTED_EDGE('',*,*,#1320,.T.);
#1340=DIRECTION('',(0.,1.,0.));
#1341=VECTOR('',#1340,1.);
#1342=CARTESIAN_POINT('',(-15.9611792061119,2.2776116924099,1.27));
#1343=LINE('',#1342,#1341);
#1344=EDGE_CURVE('E302',#50,#1319,#1343,.F.);
#1345=ORIENTED_EDGE('',*,*,#1344,.F.);
#1346=ORIENTED_EDGE('',*,*,#51,.F.);
#1347=EDGE_LOOP('',(#1338,#1339,#1345,#1346));
#1348=FACE_BOUND('',#1347,.T.);
#1349=ADVANCED_FACE('F583',(#1348),#1337,.T.);
#1350=CARTESIAN_POINT('',(-15.5611792061119,2.2776116924099,1.27));
#1351=DIRECTION('',(0.,1.,0.));
#1352=DIRECTION('',(0.,0.,1.));
#1353=AXIS2_PLACEMENT_3D('',#1350,#1351,#1352);
#1354=CYLINDRICAL_SURFACE('',#1353,0.4);
#1355=ORIENTED_EDGE('',*,*,#1281,.T.);
#1356=ORIENTED_EDGE('',*,*,#33,.F.);
#1357=DIRECTION('',(0.,1.,0.));
#1358=VECTOR('',#1357,1.);
#1359=CARTESIAN_POINT('',(-15.5611792061119,2.2776116924099,1.67));
#1360=LINE('',#1359,#1358);
#1361=CARTESIAN_POINT('',(-15.5611792061119,2.6776116924099,1.67));
#1362=VERTEX_POINT('',#1361);
#1363=EDGE_CURVE('E300',#1362,#30,#1360,.T.);
#1364=ORIENTED_EDGE('',*,*,#1363,.F.);
#1365=CARTESIAN_POINT('',(-15.5611792061119,2.6776116924099,1.27));
#1366=DIRECTION('',(0.,-1.,0.));
#1367=DIRECTION('',(0.,0.,-1.));
#1368=AXIS2_PLACEMENT_3D('',#1365,#1366,#1367);
#1369=CIRCLE('',#1368,0.4);
#1370=EDGE_CURVE('E286',#1267,#1362,#1369,.T.);
#1371=ORIENTED_EDGE('',*,*,#1370,.F.);
#1372=EDGE_LOOP('',(#1355,#1356,#1364,#1371));
#1373=FACE_BOUND('',#1372,.T.);
#1374=ADVANCED_FACE('F589',(#1373),#1354,.T.);
#1375=CARTESIAN_POINT('',(-15.5611792061119,2.6776116924099,0.870000000000001));
#1376=DIRECTION('',(0.,0.,-1.));
#1377=DIRECTION('',(-1.,0.,0.));
#1378=AXIS2_PLACEMENT_3D('',#1375,#1376,#1377);
#1379=CYLINDRICAL_SURFACE('',#1378,0.4);
#1380=DIRECTION('',(0.,0.,1.));
#1381=VECTOR('',#1380,1.);
#1382=CARTESIAN_POINT('',(-15.5611792061119,2.2776116924099,1.67));
#1383=LINE('',#1382,#1381);
#1384=CARTESIAN_POINT('',(-15.5611792061119,2.2776116924099,1.27));
#1385=VERTEX_POINT('',#1384);
#1386=EDGE_CURVE('E264',#778,#1385,#1383,.T.);
#1387=ORIENTED_EDGE('',*,*,#1386,.F.);
#1388=ORIENTED_EDGE('',*,*,#779,.F.);
#1389=ORIENTED_EDGE('',*,*,#1295,.T.);
#1390=CARTESIAN_POINT('',(-15.5611792061119,2.6776116924099,1.27));
#1391=DIRECTION('',(0.,0.,1.));
#1392=DIRECTION('',(1.,0.,0.));
#1393=AXIS2_PLACEMENT_3D('',#1390,#1391,#1392);
#1394=CIRCLE('',#1393,0.4);
#1395=EDGE_CURVE('E279',#1385,#1267,#1394,.T.);
#1396=ORIENTED_EDGE('',*,*,#1395,.F.);
#1397=EDGE_LOOP('',(#1387,#1388,#1389,#1396));
#1398=FACE_BOUND('',#1397,.T.);
#1399=ADVANCED_FACE('F280',(#1398),#1379,.T.);
#1400=CARTESIAN_POINT('',(-15.5611792061119,2.6776116924099,0.870000000000004));
#1401=DIRECTION('',(0.,0.,1.));
#1402=DIRECTION('',(1.,0.,0.));
#1403=AXIS2_PLACEMENT_3D('',#1400,#1401,#1402);
#1404=CYLINDRICAL_SURFACE('',#1403,0.4);
#1405=ORIENTED_EDGE('',*,*,#788,.F.);
#1406=ORIENTED_EDGE('',*,*,#1386,.T.);
#1407=CARTESIAN_POINT('',(-15.5611792061119,2.6776116924099,1.27));
#1408=DIRECTION('',(0.,0.,1.));
#1409=DIRECTION('',(1.,0.,0.));
#1410=AXIS2_PLACEMENT_3D('',#1407,#1408,#1409);
#1411=CIRCLE('',#1410,0.4);
#1412=EDGE_CURVE('E268',#1319,#1385,#1411,.T.);
#1413=ORIENTED_EDGE('',*,*,#1412,.F.);
#1414=ORIENTED_EDGE('',*,*,#1328,.T.);
#1415=EDGE_LOOP('',(#1405,#1406,#1413,#1414));
#1416=FACE_BOUND('',#1415,.T.);
#1417=ADVANCED_FACE('F266',(#1416),#1404,.T.);
#1418=CARTESIAN_POINT('',(-15.5611792061119,2.2776116924099,1.27));
#1419=DIRECTION('',(0.,1.,0.));
#1420=DIRECTION('',(0.,0.,1.));
#1421=AXIS2_PLACEMENT_3D('',#1418,#1419,#1420);
#1422=CYLINDRICAL_SURFACE('',#1421,0.4);
#1423=ORIENTED_EDGE('',*,*,#58,.F.);
#1424=ORIENTED_EDGE('',*,*,#1344,.T.);
#1425=CARTESIAN_POINT('',(-15.5611792061119,2.6776116924099,1.27));
#1426=DIRECTION('',(0.,-1.,0.));
#1427=DIRECTION('',(0.,0.,-1.));
#1428=AXIS2_PLACEMENT_3D('',#1425,#1426,#1427);
#1429=CIRCLE('',#1428,0.4);
#1430=EDGE_CURVE('E293',#1362,#1319,#1429,.T.);
#1431=ORIENTED_EDGE('',*,*,#1430,.F.);
#1432=ORIENTED_EDGE('',*,*,#1363,.T.);
#1433=EDGE_LOOP('',(#1423,#1424,#1431,#1432));
#1434=FACE_BOUND('',#1433,.T.);
#1435=ADVANCED_FACE('F587',(#1434),#1422,.T.);
#1436=CARTESIAN_POINT('',(-15.5611792061119,2.6776116924099,1.27));
#1437=DIRECTION('',(0.,0.,1.));
#1438=DIRECTION('',(1.,0.,0.));
#1439=AXIS2_PLACEMENT_3D('',#1436,#1437,#1438);
#1440=SPHERICAL_SURFACE('',#1439,0.4);
#1441=ORIENTED_EDGE('',*,*,#1395,.T.);
#1442=ORIENTED_EDGE('',*,*,#1370,.T.);
#1443=CARTESIAN_POINT('',(-15.5611792061119,2.6776116924099,1.27));
#1444=DIRECTION('',(1.,0.,0.));
#1445=DIRECTION('',(0.,0.,-1.));
#1446=AXIS2_PLACEMENT_3D('',#1443,#1444,#1445);
#1447=CIRCLE('',#1446,0.4);
#1448=EDGE_CURVE('E291',#1385,#1362,#1447,.F.);
#1449=ORIENTED_EDGE('',*,*,#1448,.F.);
#1450=EDGE_LOOP('',(#1441,#1442,#1449));
#1451=FACE_BOUND('',#1450,.T.);
#1452=ADVANCED_FACE('F295',(#1451),#1440,.T.);
#1453=CARTESIAN_POINT('',(-15.5611792061119,2.6776116924099,1.27));
#1454=DIRECTION('',(0.,0.,1.));
#1455=DIRECTION('',(1.,0.,0.));
#1456=AXIS2_PLACEMENT_3D('',#1453,#1454,#1455);
#1457=SPHERICAL_SURFACE('',#1456,0.4);
#1458=ORIENTED_EDGE('',*,*,#1430,.T.);
#1459=ORIENTED_EDGE('',*,*,#1412,.T.);
#1460=ORIENTED_EDGE('',*,*,#1448,.T.);
#1461=EDGE_LOOP('',(#1458,#1459,#1460));
#1462=FACE_BOUND('',#1461,.T.);
#1463=ADVANCED_FACE('F290',(#1462),#1457,.T.);
#1464=CLOSED_SHELL('',(#172,#203,#234,#256,#369,#482,#504,#521,#538,#555,#572,#589,#606,#623,
#640,#657,#674,#686,#730,#764,#808,#840,#862,#887,#912,#929,#954,#979,#997,#1015,#1032,#1043,
#1075,#1100,#1125,#1150,#1167,#1189,#1206,#1224,#1241,#1253,#1285,#1307,#1332,#1349,#1374,#1399,
#1417,#1435,#1452,#1463));
#1465=MANIFOLD_SOLID_BREP('B2',#1464);
#1466=ADVANCED_BREP_SHAPE_REPRESENTATION('',(#18,#1465),#14);
#1467=SHAPE_DEFINITION_REPRESENTATION(#9,#1466);
ENDSEC;
END-ISO-10303-21;
